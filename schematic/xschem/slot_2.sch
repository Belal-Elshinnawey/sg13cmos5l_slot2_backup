v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {sbcs.sym} 400 -1200 0 0 {name=Xsbcs}
C {level_up_shifter.sym} 210 -820 0 0 {name=Xlvl0}
C {level_up_shifter.sym} 600 -800 0 0 {name=Xlvl1}
C {devices/iopin.sym} 40 -1560 0 0 {name=p_s2_an0 lab=s2_an[0]}
C {devices/iopin.sym} 40 -1580 0 0 {name=p_s2_an1 lab=s2_an[1]}
C {devices/iopin.sym} 40 -1540 0 0 {name=p_s2_an_0_esd lab=s2_an_0_esd}
C {devices/iopin.sym} 40 -1520 0 0 {name=p_s2_an_1_esd lab=s2_an_1_esd}
C {devices/iopin.sym} 40 -1500 0 0 {name=p_vbias lab=vbias}
C {devices/ipin.sym} 40 -1480 0 0 {name=p_dig_in lab=dig_in[23:2]}
C {devices/lab_pin.sym} 130 -820 0 0 {name=p_dig_in0 sig_type=std_logic lab=dig_in[0]}
C {devices/opin.sym} 40 -1460 0 0 {name=p_dig_out lab=dig_out[11:0]}
C {devices/iopin.sym} 40 -1440 0 0 {name=p_ibias0 lab=ibias0}
C {devices/iopin.sym} 40 -1420 0 0 {name=p_ibias1 lab=ibias1}
C {devices/iopin.sym} 40 -1400 0 0 {name=p_analog_bus0 lab=analog_bus0}
C {devices/iopin.sym} 40 -1380 0 0 {name=p_analog_bus1 lab=analog_bus1}
C {devices/iopin.sym} 40 -1360 0 0 {name=p_analog_bus2 lab=analog_bus2}
C {devices/iopin.sym} 40 -1340 0 0 {name=p_analog_bus3 lab=analog_bus3}
C {devices/iopin.sym} 40 -1320 0 0 {name=p_vss_1v2 lab=vss_1v2}
C {devices/iopin.sym} 40 -1300 0 0 {name=p_vdd_1v2 lab=vdd_1v2}
C {devices/iopin.sym} 40 -1280 0 0 {name=p_vss_3v3 lab=vss_3v3}
C {devices/iopin.sym} 40 -1260 0 0 {name=p_vdd_3v3 lab=vdd_3v3}
C {devices/ipin.sym} 40 -1240 0 0 {name=p_enable lab=enable}
C {devices/ipin.sym} 40 -1220 0 0 {name=p_clk lab=clk}
C {devices/ipin.sym} 40 -1200 0 0 {name=p_reset lab=reset}
C {devices/lab_pin.sym} 400 -1300 0 0 {name=p_dig_in2 sig_type=std_logic lab=vss_3v3}
C {devices/lab_pin.sym} 400 -1320 0 0 {name=p_dig_in3 sig_type=std_logic lab=vdd_3v3}
C {devices/lab_pin.sym} 480 -1440 2 0 {name=p_dig_in4 sig_type=std_logic lab=s2_an[0]}
C {devices/lab_pin.sym} 480 -1420 2 0 {name=p_dig_in5 sig_type=std_logic lab=s2_an[1]}
C {devices/lab_pin.sym} 290 -820 2 0 {name=p_dig_in8 sig_type=std_logic lab=en}
C {devices/lab_pin.sym} 210 -740 0 0 {name=p_dig_in9 sig_type=std_logic lab=vss_3v3}
C {devices/lab_pin.sym} 600 -720 0 0 {name=p_dig_in10 sig_type=std_logic lab=vss_3v3}
C {devices/lab_pin.sym} 520 -800 0 0 {name=p_dig_in11 sig_type=std_logic lab=dig_in[1]}
C {devices/lab_pin.sym} 680 -800 2 0 {name=p_dig_in12 sig_type=std_logic lab=enb}
C {devices/lab_pin.sym} 250 -900 1 0 {name=p_dig_in13 sig_type=std_logic lab=vdd_3v3}
C {devices/lab_pin.sym} 640 -880 1 0 {name=p_dig_in14 sig_type=std_logic lab=vdd_3v3}
C {devices/lab_pin.sym} 170 -900 1 0 {name=p_dig_in15 sig_type=std_logic lab=vdd_1v2}
C {devices/lab_pin.sym} 560 -880 1 0 {name=p_dig_in16 sig_type=std_logic lab=vdd_1v2}
C {devices/lab_pin.sym} 400 -1240 0 0 {name=p_dig_in17 sig_type=std_logic lab=en}
C {devices/lab_pin.sym} 400 -1220 0 0 {name=p_dig_in18 sig_type=std_logic lab=enb}
C {noconn.sym} 40 -1200 2 0 {name=l1}
C {noconn.sym} 40 -1220 2 0 {name=l2}
C {noconn.sym} 40 -1240 2 0 {name=l3}
C {noconn.sym} 40 -1340 0 0 {name=l8}
C {noconn.sym} 40 -1400 0 0 {name=l9}
C {noconn.sym} 40 -1380 0 0 {name=l10}
C {noconn.sym} 40 -1360 0 0 {name=l11}
C {noconn.sym} 40 -1440 0 0 {name=l12}
C {noconn.sym} 40 -1420 0 0 {name=l13}
C {noconn.sym} 40 -1460 0 0 {name=l14}
C {noconn.sym} 40 -1480 2 0 {name=l15}
C {noconn.sym} 40 -1500 0 0 {name=l16}
C {noconn.sym} 40 -1520 0 0 {name=l17}
C {noconn.sym} 40 -1540 0 0 {name=l18}
C {noconn.sym} 40 -1320 0 0 {name=l4}
C {devices/ipin.sym} 310 -1480 0 0 {name=p_dig_in1 lab=dig_in[0]}
C {devices/ipin.sym} 310 -1460 0 0 {name=p_dig_in6 lab=dig_in[1]}
